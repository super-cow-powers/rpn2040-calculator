File: VFD Replacement/character.kicad_sch (KiCad schematic)
At the start: 8 parts

Commit message: Create Display PCB
Parts:
- D1: footprint (none) -> LED_SMD:LED_0402_1005Metric
